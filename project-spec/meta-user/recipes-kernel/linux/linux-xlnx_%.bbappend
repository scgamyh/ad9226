SRC_URI += "file://user_2023-04-13-15-36-00.cfg \
            file://user_2023-04-21-20-41-00.cfg \
            file://user_2023-06-29-09-35-00.cfg \
            "

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

